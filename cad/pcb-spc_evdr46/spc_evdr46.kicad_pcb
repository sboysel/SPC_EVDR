# Repository sboysel/SPC_EVDR

## KiCad design cad/pcb-spc_evdr46/spc_evdr46.kicad_pcb

Parts:
BT1: Battery_Cell; Molex_PicoBlade_53048-0210_1x02_P1.25mm_Horizontal
BZ1: Buzzer; Buzzer_Mallory_AST1109MLTRQ_reversible
C1: 0.1uF; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52: 1N4148W; D_SOD-123
J1: BL_CONN; PinHeader_1x04_P2.54mm_Vertical
L1, L2, L3: SK6812; LED_SK6812_PLCC4_5.0x5.0mm_P3.2mm
OL1: OLED; OLED_1side
R1, R2, R3: 10k; R_0805_2012Metric
SW1, SW2, SW3, SW4, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW46, SW47: SW_Push; CherryMX_Hotswap
SW5: EC11; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm-keebio_modif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
SW13: ON_OFF; switch_MSK-12C02_smd
SW42, SW45, SW49, SW51: SW_Push; Inv_CherryMX_Hotswap_1.25u
SW43, SW44, SW50, SW52: SW_Push; Inv_CherryMX_Hotswap_1.5u
SW48: SW_Push; CherryMX_1u
SW53: SW_Push; Micro_Push_Button_3x6x2.5mm
SW54: SKQUCAA010; Mouser Part Number 688-SKQUCA
U1: PCA9555PW; TSSOP-24_4.4x7.8mm_P0.65mm
U2: xiao-ble; xiao-ble-smd-cutout
U3: Pimoroni haptic buzz; Pimoroni Haptic Buzz DRV2605L Driver

Connections:
+3V3: C1.2, J1.2, OL1.3 (VCC), R1.1, R2.1, R3.1, U1.24 (VDD), U2.12 (3V3), U3.1
+5V: L1.3 (VDD), L2.3 (VDD), L3.3 (VDD), U2.14 (5V)
AUDIO: BZ1.1 (-), U2.7 (B8_TX/1.11)
Col_0: SW1.1, SW15.1, SW27.1, SW39.1, U1.8 (IO0_4)
Col_1: SW2.1, SW16.1, SW28.1, SW40.1, U1.4 (IO0_0)
Col_2: SW3.1, SW17.1, SW29.1, SW41.1, U1.5 (IO0_1)
Col_3: SW4.1, SW5.S1, SW18.1, SW30.1, U1.6 (IO0_2)
Col_4: SW6.1, SW19.1, SW31.1, SW49.1, SW50.1, U1.7 (IO0_3)
Col_5: SW7.1, SW20.1, SW32.1, SW42.1, SW43.1, U1.13 (IO1_0)
Col_6: SW8.1, SW21.1, SW33.1, SW44.1, SW45.1, U1.9 (IO0_5)
Col_7: D50.2 (A), SW9.1, SW22.1, SW34.1, SW51.1, SW52.1, U1.10 (IO0_6)
Col_8: D49.2 (A), SW10.1, SW23.1, SW35.1, U1.11 (IO0_7)
Col_9: D48.2 (A), SW11.1, SW24.1, SW36.1, SW46.1, U1.17 (IO1_4)
Col_10: D52.2 (A), SW12.1, SW25.1, SW37.1, SW47.1, U1.19 (IO1_6)
Col_11: D51.2 (A), SW14.1, SW26.1, SW38.1, SW48.1, U1.14 (IO1_1)
GND: BT1.2 (-), BZ1.2 (+), C1.1, J1.1, L1.1 (VSS), L2.1 (VSS), L3.1 (VSS), OL1.4 (GND), SW5.C, SW53.2, U1.2 (A1), U1.3 (A2), U1.12 (VSS), U1.21 (A0), U2.13 (GND), U2.18 (GND), U2.20 (GND), U3.5
LED: L1.2 (DIN), U2.3 (A10/0.28)
unnamed: BT1.1 (+), SW13.1
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW6.2
unnamed: D6.2 (A), SW7.2
unnamed: D7.2 (A), SW8.2
unnamed: D8.2 (A), SW9.2
unnamed: D9.2 (A), SW10.2
unnamed: D10.2 (A), SW11.2
unnamed: D11.2 (A), SW12.2
unnamed: D12.2 (A), SW14.2
unnamed: D13.2 (A), SW15.2
unnamed: D14.2 (A), SW16.2
unnamed: D15.2 (A), SW17.2
unnamed: D16.2 (A), SW18.2
unnamed: D17.2 (A), SW19.2
unnamed: D18.2 (A), SW20.2
unnamed: D19.2 (A), SW21.2
unnamed: D20.2 (A), SW22.2
unnamed: D21.2 (A), SW23.2
unnamed: D22.2 (A), SW24.2
unnamed: D23.2 (A), SW25.2
unnamed: D24.2 (A), SW26.2
unnamed: D25.2 (A), SW27.2
unnamed: D26.2 (A), SW28.2
unnamed: D27.2 (A), SW29.2
unnamed: D28.2 (A), SW30.2
unnamed: D29.2 (A), SW31.2
unnamed: D30.2 (A), SW32.2
unnamed: D31.2 (A), SW33.2
unnamed: D32.2 (A), SW34.2
unnamed: D33.2 (A), SW35.2
unnamed: D34.2 (A), SW36.2
unnamed: D35.2 (A), SW37.2
unnamed: D36.2 (A), SW38.2
unnamed: D37.2 (A), SW39.2
unnamed: D38.2 (A), SW40.2
unnamed: D39.2 (A), SW5.S2
unnamed: D40.2 (A), SW41.2
unnamed: D41.2 (A), SW49.2, SW50.2
unnamed: D42.2 (A), SW42.2, SW43.2
unnamed: D43.2 (A), SW44.2, SW45.2
unnamed: D44.2 (A), SW51.2, SW52.2
unnamed: D45.2 (A), SW46.2
unnamed: D46.2 (A), SW47.2
unnamed: D47.2 (A), SW48.2
unnamed: D48.1 (K), SW54.1
unnamed: D49.1 (K), SW54.2
unnamed: D50.1 (K), SW54.3
unnamed: D51.1 (K), SW54.6
unnamed: D52.1 (K), SW54.5
unnamed: L1.4 (DOUT), L2.2 (DIN)
unnamed: L2.4 (DOUT), L3.2 (DIN)
unnamed: R1.2, U1.1 (~INT)
unnamed: SW13.2, U2.19 (BAT)
Row_0: SW54.4, U2.4 (A11/0.29)
Row_1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U2.8 (B9_RX/1.12)
Row_2: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U2.9 (A7_SCK/1.13)
Row_3: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U2.10 (A5_MISO/1.14)
Row_4: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), U2.11 (A6_MOSI/1.15)
encA: SW5.A, U2.1 (A2/0.02_H)
encB: SW5.B, U2.2 (A4/0.03_H)
rst: SW53.1, U2.17 (RESET)
scl: OL1.2 (SCL), R2.2, U1.22 (SCL), U2.6 (A9_SCL/0.05_H), U3.3
sda: OL1.1 (SDA), R3.2, U1.23 (SDA), U2.5 (A8_SDA/0.04_H), U3.2
swclk: J1.4, U2.16 (A30_SWCLK)
swdio: J1.3, U2.15 (A31_SWDIO)

Notes on the sheet:
Status OLED display
PCA95XXPW
Speaker
Seeeduino XIAO RP2040/BLE
5-way switch
Serial wire
Status RGBW LEDs
Haptic buzzer i2c
Top left rotary encoder

Board: 2 copper layers, 237.6 x 100.5 mm, 120 parts (57 on the bottom side), 86 nets.

## Commit log

2023-04-17 added case; kicad libraries are probably broken
2023-05-29 adding flat versions of case top and bottom
